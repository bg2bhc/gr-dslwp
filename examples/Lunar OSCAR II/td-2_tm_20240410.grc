options:
  parameters:
    generate_options: qt_gui
    id: td2_tm
    output_language: python
    title: TD-2 TM
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: baud_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@1:5,0
    label0: 256 bps
    label1: 512 bps
    label2: 1024 bps
    num_opts: '3'
    option0: '256'
    option1: '512'
    option2: '1024'
    type: int
    value: '256'
  states: {}
- name: carrier_loop_bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:4,0
    type: real
    value: '100'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:6,0
    type: real
    value: '0.01'
  states: {}
- name: f_offset_rx
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:1,0
    type: real
    value: '0'
  states: {}
- name: f_offset_tx
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:2,0
    type: real
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@1:0,0
    label0: 'TD-1: 2222.808 MHz'
    label1: 'TD-2: 2275.224 MHz'
    num_opts: '2'
    option0: 2222.808e6
    option1: 2275.224e6
    type: real
    value: 2275.224e6
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1:3,0
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '73'
    value: '35'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: 4096/baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: waterfall_update_period
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@1:7,0
    type: real
    value: '0.1'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '2'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 2*3.14*10e3/samp_rate
    min_freq: '-2*3.14*10e3/samp_rate'
    w: 2*3.14*carrier_loop_bw/samp_rate
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: 2*3.14*10e3/samp_rate
    min_freq: '-2*3.14*10e3/samp_rate'
    w: 2*3.14*carrier_loop_bw/samp_rate
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-65536'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 125e3+f_offset_rx
    offset: '0'
    phase: '0'
    samp_rate: 0.5e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: ''
    file: /home/lilac/td2_20250210_meta.raw
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/lilac/grc_td2/td2_data_20240307b.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lilac/td2/td_2.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/2/3.1415926529
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '3070'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop_bw
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    check_length: 'False'
    data_format: '2'
    marker: '[0x1a, 0xcf, 0xfc, 0x1d]'
    msg_len: '0'
    pass_other_length: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: lilacsat_sync_det_b_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '252'
    nrz: 'False'
    sync_word: '0x1ACFFC1D'
  states: {}
- name: lilacsat_sync_det_b_0_0
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '252'
    nrz: 'False'
    sync_word: '0x1ACFFC1D'
  states: {}
- name: lilacsat_sync_det_b_0_1
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '252'
    nrz: 'False'
    sync_word: '0x1ACFFC1D'
  states: {}
- name: lilacsat_sync_det_b_0_2
  id: lilacsat_sync_det_b
  parameters:
    descrambling: 'True'
    len: '252'
    nrz: 'False'
    sync_word: '0x1ACFFC1D'
  states: {}
- name: lilacsat_vitfilt27_fb_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: lilacsat_vitfilt27_fb_0_0
  id: lilacsat_vitfilt27_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baud_rate*1
    decim: '1'
    gain: '1'
    samp_rate: '4096'
    type: fir_filter_ccf
    width: baud_rate*0.5
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: A
    legend: 'False'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: 0,0,1,1
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '4096'
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,0,1,1
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-90'
    ymin: '-130'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: 0,1,1,1
    label1: real
    label2: imag
    nconnections: '2'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-80'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: 1.2e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 8,0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,1,1,1
    label1: Eb/N0
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,0,1,1
    label1: Doppler
    name: ''
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: tab@0:1,0
    int_max: '-80'
    int_min: '-120'
    showports: 'True'
    type: complex
    update_time: waterfall_update_period
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.45'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1875'
    fbw: '0.45'
    interp: '32'
    taps: ''
    type: ccc
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: '1'
    gfpoly: '285'
    interleave: '1'
    nroots: '1'
    nsym: '8'
    prim: '1'
  states: {}
- name: satellites_encode_rs_0
  id: satellites_encode_rs
  parameters:
    fcr: '1'
    gfpoly: '285'
    interleave: '1'
    nroots: '1'
    nsym: '8'
    prim: '1'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,2,4,1
    label0: Waterfall
    label1: Config
    num_tabs: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: 70e6+125e3
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: '""'
    dev_args: '"type=b200"'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: 0.5e6
    sd_spec0: A:A
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', hilbert_fc_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_1, '1']
- [blocks_complex_to_float_1, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_float_1, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_1, '0', lilacsat_vitfilt27_fb_0, '0']
- [blocks_complex_to_float_1, '1', blocks_rms_xx_0, '0']
- [blocks_delay_0, '0', lilacsat_vitfilt27_fb_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1_0, '0', rational_resampler_xxx_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_not_xx_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [blocks_not_xx_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', blocks_file_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_unpack_k_bits_bb_0_0_0, '0', lilacsat_sync_det_b_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', lilacsat_sync_det_b_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', lilacsat_sync_det_b_0_2, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', lilacsat_sync_det_b_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_float_1, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [dslwp_attach_sync_marker_0, out, blocks_message_debug_0, print_pdu]
- [dslwp_attach_sync_marker_0, out, blocks_pdu_to_tagged_stream_1, pdus]
- [dslwp_attach_sync_marker_0, out, blocks_socket_pdu_0, pdus]
- [hilbert_fc_0, '0', blocks_multiply_xx_1_0, '0']
- [lilacsat_sync_det_b_0, out, satellites_decode_rs_0, in]
- [lilacsat_sync_det_b_0_0, out, satellites_decode_rs_0, in]
- [lilacsat_sync_det_b_0_1, out, satellites_decode_rs_0, in]
- [lilacsat_sync_det_b_0_2, out, satellites_decode_rs_0, in]
- [lilacsat_vitfilt27_fb_0, '0', blocks_not_xx_0, '0']
- [lilacsat_vitfilt27_fb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [lilacsat_vitfilt27_fb_0_0, '0', blocks_not_xx_0_0, '0']
- [lilacsat_vitfilt27_fb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1, '0']
- [low_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [rational_resampler_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [rational_resampler_xxx_0, '0', analog_pll_freqdet_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_meta_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0_1, '0']
- [satellites_decode_rs_0, out, satellites_encode_rs_0, in]
- [satellites_encode_rs_0, out, dslwp_attach_sync_marker_0, in]
- [uhd_usrp_source_0, '0', blocks_multiply_xx_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_2, '0']

metadata:
  file_format: 1
