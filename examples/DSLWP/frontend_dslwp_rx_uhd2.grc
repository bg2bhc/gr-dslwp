options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: frontend_dslwp_rx_uhd2
    output_language: python
    title: Frontend DSLWP RX UHD2
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: f_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency Offset
    type: real
    value: '0'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '73'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: waterfall_ch_max
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: waterfall_ch_min
  id: variable
  parameters:
    value: '-100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 575e3+f_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 600e3+f_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-425e3+f_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-400e3+f_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7160'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8160'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7161'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7176'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_sink_0_1_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8176'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_sink_0_1_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7177'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1_1_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8177'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1_2
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8161'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    gui_hint: tab3@1:0,0
    name: '"Spectrum-V"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    gui_hint: tab3@1:0,1
    name: '"Spectrum-H"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: tab3@0:0,0
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall-V"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.425e6
    fftsize: '1024'
    gui_hint: tab1@0:0,0
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"A0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.4e6
    fftsize: '1024'
    gui_hint: tab2@0:0,0
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"B0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 436.425e6
    fftsize: '1024'
    gui_hint: tab1@0:0,1
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"A1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 436.4e6
    fftsize: '1024'
    gui_hint: tab2@0:0,1
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"B1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 436.4e6
    fftsize: '1024'
    gui_hint: tab2@1:0,1
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"B1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 436.425e6
    fftsize: '1024'
    gui_hint: tab1@1:0,1
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"A1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.4e6
    fftsize: '1024'
    gui_hint: tab2@1:0,0
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"B0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.425e6
    fftsize: '1024'
    gui_hint: tab1@1:0,0
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"A0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: tab3@0:0,1
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall-H"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,2
    label0: BJ1SM-V
    label1: BJ1SM-H
    num_tabs: '2'
  states: {}
- name: tab2
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: BJ1SN-V
    label1: BJ1SN-H
    num_tabs: '2'
  states: {}
- name: tab3
  id: qtgui_tab_widget
  parameters:
    gui_hint: 5,0,1,2
    label0: Waterfall
    label1: Spectrum
    num_tabs: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: fc
    center_freq1: fc
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_2, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_0_1_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', rational_resampler_xxx_0_0_1, '0']
- [blocks_multiply_xx_0_0_0_0, '0', rational_resampler_xxx_0_0_1_0, '0']
- [blocks_multiply_xx_0_0_1, '0', rational_resampler_xxx_0_0_2, '0']
- [blocks_multiply_xx_0_0_1_0, '0', rational_resampler_xxx_0_0_2_0, '0']
- [blocks_multiply_xx_0_0_2, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_xx_0_1, '0', rational_resampler_xxx_0_1, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_udp_sink_0_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_udp_sink_0_1_2, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_1, '0', blocks_udp_sink_0_1_0, '0']
- [rational_resampler_xxx_0_0_1, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_1_0, '0', blocks_udp_sink_0_1_0_0, '0']
- [rational_resampler_xxx_0_0_1_0, '0', qtgui_waterfall_sink_x_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_2, '0', blocks_udp_sink_0_1_1, '0']
- [rational_resampler_xxx_0_0_2, '0', qtgui_waterfall_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_2_0, '0', blocks_udp_sink_0_1_1_0, '0']
- [rational_resampler_xxx_0_0_2_0, '0', qtgui_waterfall_sink_x_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_udp_sink_0_0, '0']
- [rational_resampler_xxx_0_1, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0_0_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0_0_1_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0_0_2, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0_1, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_waterfall_sink_x_0_1, '0']

metadata:
  file_format: 1
