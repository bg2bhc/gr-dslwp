options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: frontedn_dslwp_replay
    output_language: python
    title: Frontend DSLWP Replay
  states: {}

blocks:
- name: amp_rec
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0
    label: 'Recording Amplitude '
    type: real
    value: '0.0405'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: cn0
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0
    label: C/N0
    type: real
    value: '60'
  states: {}
- name: f_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0
    label: Frequency Offset
    type: real
    value: '-500'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: waterfall_ch_max
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: waterfall_ch_min
  id: variable
  parameters:
    value: '-100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amp_rec
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 575e3+f_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 600e3+f_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-425e3+f_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-400e3+f_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lilac/record_dslwp_beacon_0505_part0.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (10.0**(cn0/10.0)/samp_rate)**0.5
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7160'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7161'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7176'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7177'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    gui_hint: tab@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2
    label1: ''
    name: '"Recording Amplitude"'
    size: '7280'
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    gui_hint: tab@0
    int_max: '0'
    int_min: '-100'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.425e6
    fftsize: '1024'
    gui_hint: 4,0
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"BJ1SM-A0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.4e6
    fftsize: '1024'
    gui_hint: 5,0
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"BJ1SN-B0"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.4e6
    fftsize: '1024'
    gui_hint: 4,1
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"BJ1SM-A1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 40e3
    color1: '2'
    fc: 435.4e6
    fftsize: '1024'
    gui_hint: 5,1
    int_max: waterfall_ch_max
    int_min: waterfall_ch_min
    name: '"BJ1SN-B1"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 6,0,1,2
    label0: Waterfall
    label1: Spectrum
    label2: Recording Amplitude
    num_tabs: '3'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', rational_resampler_xxx_0_0_1, '0']
- [blocks_multiply_xx_0_0_1, '0', rational_resampler_xxx_0_0_2, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_udp_sink_0_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', blocks_udp_sink_0_1_0, '0']
- [rational_resampler_xxx_0_0_1, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_2, '0', blocks_udp_sink_0_1_1, '0']
- [rational_resampler_xxx_0_0_2, '0', qtgui_waterfall_sink_x_0_0_0_0_0, '0']

metadata:
  file_format: 1
