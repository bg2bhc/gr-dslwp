options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: frontend_dslwp_tx_open_wav
    output_language: python
    title: frontend_dslwp_tx_open_wav
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: '8000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '8000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(5, [0x83, 0x20, 0x72, 0x00, 0x00]))
    period: '3000'
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 192.168.2.180
    mtu: '10000'
    port: '60060'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: audio.wav
    samp_rate: '8000'
  states: {}
- name: dslwp_lrtc_mod_bc_0
  id: dslwp_lrtc_mod_bc
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lilacsat_fec_encode_b_0
  id: lilacsat_fec_encode_b
  parameters:
    continous: 'False'
    frame_len: '32'
    padding_zero: 'False'
    preamble_len: '5'
    trailer_len: '5'
    using_convolutional_code: 'False'
    using_m: 'False'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, lilacsat_fec_encode_b_0, in]
- [blocks_multiply_xx_0_1, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_message_debug_1, print_pdu]
- [blocks_socket_pdu_0_0, pdus, lilacsat_fec_encode_b_0, in]
- [dslwp_lrtc_mod_bc_0, '0', rational_resampler_xxx_0_1, '0']
- [lilacsat_fec_encode_b_0, '0', dslwp_lrtc_mod_bc_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_xx_0_1, '1']

metadata:
  file_format: 1
