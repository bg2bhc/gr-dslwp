options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: uhd_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 50e3
    maxoutbuf: '4096'
    offset: '0'
    phase: '0'
    samp_rate: uhd_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(223, [0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,208,209,210,211,212,213,214,215,216,217,218,219,220,221,222]))
    period: '14560'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1,-1]'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
  states: {}
- name: dslwp_attach_sync_marker_0
  id: dslwp_attach_sync_marker
  parameters:
    data_format: '1'
    marker: '[0x03,0x47,0x76,0xC7,0x27,0x28,0x95,0xB0]'
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '1'
  states: {}
- name: dslwp_ccsds_turbo_encode_0
  id: dslwp_ccsds_turbo_encode
  parameters:
    base: '223'
    code_type: '2'
    octets: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: uhd_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '512'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: 435.35e6
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: uhd_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_delay_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_message_strobe_0_0, strobe, dslwp_ccsds_turbo_encode_0, in]
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_xx_0_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_1_0, '0', blocks_multiply_xx_0_1, '1']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_time_sink_x_1, '0']
- [digital_gmsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [dslwp_attach_sync_marker_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [dslwp_ccsds_pseudo_randomizer_0_0, out, dslwp_attach_sync_marker_0, in]
- [dslwp_ccsds_turbo_encode_0, out, dslwp_ccsds_pseudo_randomizer_0_0, in]
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
