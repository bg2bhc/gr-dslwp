options:
  parameters:
    category: '[DSLWP]'
    generate_options: hb
    id: fft_correlator_hier
    output_language: python
    title: FFT Correlator Hier
  states: {}

blocks:
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: taps
    type: complex
    vlen: tap_len
  states: {}
- name: dslwp_fft_estimator_cc_0
  id: dslwp_fft_estimator_cc
  parameters:
    fft_size: fft_size
    tap_len: tap_len
    threshold: threshold
  states: {}
- name: dslwp_steam_to_vector_moving_window_cc_0
  id: dslwp_steam_to_vector_moving_window_cc
  parameters:
    vlen: tap_len
  states: {}
- name: dslwp_vector_padding_cc_0
  id: dslwp_vector_padding_cc
  parameters:
    padding: '0'
    position: '0'
    vlen_in: tap_len
    vlen_out: fft_size
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: '512'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: nthreads
    shift: 'False'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: nthreads
  id: parameter
  parameters:
    label: Num. Threads
    type: intx
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    showports: 'True'
    vlen: fft_size
    x_axis_label: '"Frequency"'
    x_start: '0'
    x_step: 2*math.pi/fft_size
    y_axis_label: '"Amplitude"'
    ymax: '2'
    ymin: '0'
  states: {state: disabled}
- name: tap_len
  id: parameter
  parameters:
    label: Tap Length
    type: intx
    value: '512'
  states: {}
- name: taps
  id: parameter
  parameters:
    label: Taps
    value: '[1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0.125'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', dslwp_vector_padding_cc_0, '0']
- [dslwp_fft_estimator_cc_0, '0', pad_sink_0, '0']
- [dslwp_steam_to_vector_moving_window_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [dslwp_vector_padding_cc_0, '0', dslwp_fft_estimator_cc_0, '1']
- [dslwp_vector_padding_cc_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', dslwp_fft_estimator_cc_0, '0']
- [pad_source_0, '0', dslwp_steam_to_vector_moving_window_cc_0, '0']

metadata:
  file_format: 1
